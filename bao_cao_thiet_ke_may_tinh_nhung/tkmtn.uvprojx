# Keil uVision project tkmtn.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: MKL46Z256VLL4 NXP
  pack: NXP.MKL46Z4_DFP.10.0.3
  cpu: IRAM(0x1fffe000,0x8000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: tkmtn
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  group Source Group 1
    ./: main.c checkingSignal.h checkinVehicle.c checkSeatFastened.c lch.h warning_display.c init_timer.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
